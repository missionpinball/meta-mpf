SUMMARY = "MPF pygame/skeleton base image"

# IMAGE_FEATURES += "splash"

LICENSE = "MIT"

inherit core-image

CORE_IMAGE_EXTRA_INSTALL = "python python-datetime python-io python-core python-misc python-pygame"
